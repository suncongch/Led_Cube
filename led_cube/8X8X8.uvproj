# Keil uVision project 8X8X8.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC12C5A16S2 Series
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 8X8X8 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 8X8X8.c flash.c math.c delay.c config.c
  group include
    ./: config.h INTRINS.h REG52.h math.h delay.h flash.h
